# Repository icamaster/AAC_ClassDAmplifier

File README.md:

# AAC_ClassDAmplifier
Class D amplifier project for AllAboutCircuits.com

## KiCad design Kicad/ClassDAmplifier-555LM393IR2110-V3.kicad_pcb

Board: 2 copper layers, 57 parts (1 on the bottom side), 30 nets.

Parts:
C1, C3: 1n; C_Rect_L7_W2_P5
C2: 10uF; C_Radial_D5_L11_P2
C4, C5, C6, C7, C8, C9: 47uF; C_Radial_D5_L11_P2
C10: 22uF; C_Radial_D5_L11_P2
C11: 100n; C_0805_HandSoldering
C12, C13: 220n; C_Rect_L13_W4_P10
C15, C18: 470nF; C_Rect_L18_W11_H19_P15
D1, D2: 5V1; Diode_DO-41_SOD81_Horizontal_RM10
D3: 12V; Diode_DO-41_SOD81_Horizontal_RM10
D4, D5, D7, D8: 1N4148; Diode_DO-35_SOD27_Horizontal_RM10
D6: MUR120; Diode_DO-41_SOD81_Horizontal_RM10
F1, F2: 6A; Fuseholder5x20_horiz_open_inline_Type-I
L1: 22uH; Inductor_T106-2
P1: Input; PINHEAD1-2
P2, P6: GND; Blade_Conn
P3: +30; Blade_Conn
P4: -30; Blade_Conn
P5: OUT; Blade_Conn
Q1, Q2: 2N5401; TO-92_Inline_Narrow_Oval
Q3: BC241C; TO-220_Neutral123_Vertical
Q4, Q5: IRF540N; TO-220
R1: 330k; Resistor_Horizontal_RM10mm
R2: 2k2; Resistor_Horizontal_RM10mm
R3: 3.3k; Resistor_Horizontal_RM10mm
R4, R5: 1K-2W; Resistor_Horizontal_RM15mm
R6, R7, R8, R9: 1k; Resistor_Horizontal_RM10mm
R10, R11: 10k; Resistor_Horizontal_RM10mm
R12: 10k; Resistor_Vertical_RM5mm
R13, R14: 6.8k; Resistor_Horizontal_RM10mm
R15, R16: 10; Resistor_Horizontal_RM10mm
U1: LMC555CN; DIP-8_W7.62mm_LongPads
U2: LM393; DIP-8_W7.62mm_LongPads
U3: LM7805CT; TO-220
U4: IR2110; DIP-14_W7.62mm_LongPads

Connections:
+5V: C4.1, D1.1, R4.2, R6.1, R7.1, R10.2, R11.2, U1.8, U2.8
+5V_2: C8.1, D4.1, D5.1, U3.3, U4.9
+12V: C7.1, C9.1, D6.2, Q3.3, U3.1, U4.3
+30V: C12.1, F1.2, Q4.2, R4.1
-5V: C1.1, C5.2, D2.2, R5.2, U1.1, U2.4
-30V: C6.2, C7.2, C8.2, C9.2, C13.1, D3.2, F2.2, Q5.3, R5.1, R13.2, R14.2, U3.2, U4.2, U4.11, U4.13
GND: C3.2, C4.2, C5.1, C12.2, C13.2, C15.2, C18.2, D1.2, D2.1, P1.1, P2.1, P6.1, Q3.2, R1.1, R12.1
unnamed: C2.1, R1.2, R2.2
unnamed: C2.2, P1.2
unnamed: C3.1, R2.1, U2.2, U2.5
unnamed: C6.1, D3.1, Q3.1, R12.2
unnamed: C10.1, C11.1, D6.1, U4.6
unnamed: C10.2, C11.2, L1.1, Q4.3, Q5.2, U4.5
unnamed: C15.1, C18.1, L1.2, P5.1
unnamed: D4.2, Q1.3, R13.1, U4.10
unnamed: D5.2, Q2.3, R14.1, U4.12
unnamed: D7.1, R15.2, U4.7
unnamed: D7.2, Q4.1, R15.1
unnamed: D8.1, R16.2, U4.1
unnamed: D8.2, Q5.1, R16.1
unnamed: F1.1, P3.1
unnamed: F2.1, P4.1
unnamed: Q1.1, R10.1
unnamed: Q1.2, R8.1
unnamed: Q2.1, R11.1
unnamed: Q2.2, R9.1
unnamed: R3.1, U1.3
unnamed: R6.2, R8.2, U2.1
unnamed: R7.2, R9.2, U2.7
triangle: C1.2, R3.2, U1.2, U1.6, U2.3, U2.6
